# IAR project STM8S_Demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 2
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: F:\workplace\wireless_control\code\CC1101-zhoucheng\CC1101-zhoucheng_20200104\STM8 RX\FWlib\inc; F:\workplace\wireless_control\code\CC1101-zhoucheng\CC1101-zhoucheng_20200104\STM8 RX\USER
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8S_RX.hex
  ILINK.IlinkOutputFile: STM8S_Demo.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group FWLib
    ../FWlib/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_uart2.c stm8s_wwdg.c
  group USER
    ../USER/: CC1101.c LED.c main.c power.c stm8s_it.c
